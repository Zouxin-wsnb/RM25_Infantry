# Keil uVision project Chassis.uvprojx, settings and files
target Chassis (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Src/BSP;../Src/BSP/can;../Src/BSP/dwt;../Src/BSP/gpio;../Src/BSP/iic;../Src/BSP/pwm;../Src/BSP/spi;../Src/BSP/tim;../Src/BSP/usart;../Src/ChassisController;../Src/Entity/board_connectivity;../Src/Entity/buzzer;../Src/Entity/daemon;../Src/Entity/GMMotor;../Src/Entity/LED;..\Src\Utility;../Src/Entity/Monitor;../Src/Entity/SuperCap;..\Src\Entity\Referee;../Middlewares/ST/ARM/DSP/Inc;..\Src\Entity\rmuc2024_jlui
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Entity
    ../Src/Entity/board_connectivity/: BoardConnectivity.cpp
    ../Src/Entity/GMMotor/: GM2006.cpp GM3508.cpp GM6020.cpp GMMotorHandler.cpp
    ../Src/Entity/Monitor/: Monitor.cpp
    ../Src/Entity/LED/: LED.cpp
    ../Src/Entity/Referee/: Referee.cpp jlui.cpp
  group BSP
    ../Src/BSP/: bsp.cpp
    ../Src/BSP/can/: bsp_can.cpp
    ../Src/BSP/dwt/: bsp_dwt.cpp
    ../Src/BSP/gpio/: bsp_gpio.cpp
    ../Src/BSP/usart/: bsp_usart.cpp
  group Controller
    ../Src/ChassisController/: ChassisController.cpp
  group Utility
    ../Src/Utility/: Math.cpp Pid.cpp FirstOrderFilter.cpp crc.cpp KalmanFilter.cpp
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
